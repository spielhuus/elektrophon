.title KiCad schematic
R1 +15V Net-_R1-Pad2_ 150k
R2 Net-_R1-Pad2_ Net-_R2-Pad2_ 47k
XU1 Net-_R12-Pad1_ Net-_R12-Pad2_ Net-_R1-Pad2_ +15V Net-_R13-Pad2_ Net-_R2-Pad2_ Net-_Q1-Pad3_ Net-_Q2-Pad3_ Net-_R3-Pad2_ Net-_R14-Pad2_ -15V Net-_R10-Pad1_ Net-_R4-Pad2_ Net-_Q3-Pad3_ LMx24
R12 Net-_R12-Pad1_ Net-_R12-Pad2_ 100k
R7 Net-_R12-Pad2_ CV 10k
R13 Net-_Q1-Pad3_ Net-_R13-Pad2_ 100k
R8 Net-_R13-Pad2_ CV 10k
R14 Net-_Q2-Pad3_ Net-_R14-Pad2_ 100k
R9 Net-_R14-Pad2_ CV 10k
R15 Net-_Q3-Pad3_ Net-_R10-Pad1_ 100k
R10 Net-_R10-Pad1_ CV 10k
R3 Net-_R2-Pad2_ Net-_R3-Pad2_ 47k
R4 Net-_R3-Pad2_ Net-_R4-Pad2_ 47k
XU2 Net-_Q4-Pad3_ Net-_R11-Pad1_ Net-_R5-Pad2_ +15V GND Net-_R25-Pad1_ OUT NC_01 NC_02 NC_03 -15V NC_04 NC_05 NC_06 LMx24
R16 Net-_Q4-Pad3_ Net-_R11-Pad1_ 100k
R11 Net-_R11-Pad1_ CV 10k
R5 Net-_R4-Pad2_ Net-_R5-Pad2_ 47k
R6 Net-_R5-Pad2_ -15V 150k
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ Net-_Q1-Pad3_ BC857CW
R17 Net-_R12-Pad1_ Net-_Q1-Pad1_ 47k
Q2 Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ NC_07 BC857CW
R18 Net-_Q1-Pad3_ Net-_Q2-Pad1_ 47k
Q3 Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ Net-_Q3-Pad3_ BC857CW
R19 NC_08 Net-_Q3-Pad1_ 47k
R20 Net-_Q3-Pad3_ Net-_Q4-Pad1_ 47k
Q4 Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ Net-_Q4-Pad3_ BC857CW
XU5 Net-_R22-Pad1_ NC_09 INPUT_B GND Net-_R26-Pad2_ -15V NC_10 NC_11 NC_12 NC_13 +15V Net-_R25-Pad2_ GND INPUT_A NC_14 Net-_R21-Pad1_ LM13700/NS
R21 Net-_R21-Pad1_ Net-_Q1-Pad2_ 39k
R22 Net-_R22-Pad1_ Net-_Q2-Pad2_ 39k
XU6 Net-_R24-Pad1_ NC_15 INPUT_D GND Net-_R28-Pad2_ -15V +15V Net-_R27-Pad2_ GND INPUT_C NC_16 Net-_R23-Pad1_ LM13700/NS
R23 Net-_R23-Pad1_ Net-_Q3-Pad2_ 39k
R24 Net-_R24-Pad1_ Net-_Q4-Pad2_ 39k
R25 Net-_R25-Pad1_ Net-_R25-Pad2_ 100k
R26 Net-_R25-Pad1_ Net-_R26-Pad2_ 100k
R27 Net-_R25-Pad1_ Net-_R27-Pad2_ 100k
R28 Net-_R25-Pad1_ Net-_R28-Pad2_ 100k
R29 OUT Net-_R25-Pad1_ 100k
.end
