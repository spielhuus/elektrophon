.title KiCad schematic
VJ1 Net-_J1-PadT_ GND dc 5 ac 0 sin(0 5 1k)
R3 Net-_R27-Pad2_ Net-_J2-PadT_ 1k
XRV1 GND Net-_R4-Pad1_ Net-_J1-PadT_ voltage_divider
R1 Net-_R1-Pad1_ Net-_J1-PadT_ 100k
R2 /MIX_1 Net-_R1-Pad1_ 100k
XU1 Net-_R4-Pad1_ Net-_R1-Pad1_ +15V -15V /MIX_1 OPA2134
R4 Net-_R4-Pad1_ Net-_J1-PadT_ 33k
R5 GND Net-_R4-Pad1_ 33k
R21 /MIX_1 Net-_R10-Pad2_ 100k
R25 Net-_R10-Pad2_ Net-_R25-Pad2_ 100k
R26 Net-_R25-Pad2_ Net-_R26-Pad2_ 100k
R27 Net-_R26-Pad2_ Net-_R27-Pad2_ 100k
XU2 GND Net-_R10-Pad2_ +15V -15V Net-_R25-Pad2_ OPA2134
XU3 GND Net-_R26-Pad2_ +15V -15V Net-_R27-Pad2_ OPA2134
VJ3 Net-_J3-PadT_ GND dc 5 sin(0 5 2k)
XRV2 GND Net-_R6-Pad1_ Net-_J3-PadT_ voltage_divider
R8 Net-_R8-Pad1_ Net-_J3-PadT_ 100k
R9 /MIX_2 Net-_R8-Pad1_ 100k
XU4 Net-_R6-Pad1_ Net-_R8-Pad1_ +15V -15V /MIX_2 OPA2134
R6 Net-_R6-Pad1_ Net-_J3-PadT_ 33k
R7 GND Net-_R6-Pad1_ 33k
R10 /MIX_2 Net-_R10-Pad2_ 100k
VJ4 Net-_J4-PadT_ GND dc 5 sin(0 5 4k)
XRV3 GND Net-_R11-Pad1_ Net-_J4-PadT_ voltage_divider
R13 Net-_R13-Pad1_ Net-_J4-PadT_ 100k
R14 /MIX_3 Net-_R13-Pad1_ 100k
XU5 Net-_R11-Pad1_ Net-_R13-Pad1_ +15V -15V /MIX_3 OPA2134
R11 Net-_R11-Pad1_ Net-_J4-PadT_ 33k
R12 GND Net-_R11-Pad1_ 33k
R19 /MIX_3 Net-_R10-Pad2_ 100k
VJ5 Net-_J5-PadT_ GND dc 5 sin(0 5 8k)
XRV4 GND Net-_R15-Pad1_ Net-_J5-PadT_ voltage_divider
R17 Net-_R17-Pad1_ Net-_J5-PadT_ 100k
R18 /MIX_4 Net-_R17-Pad1_ 100k
XU6 Net-_R15-Pad1_ Net-_R17-Pad1_ +15V -15V /MIX_4 OPA2134
R15 Net-_R15-Pad1_ Net-_J5-PadT_ 33k
R16 GND Net-_R15-Pad1_ 33k
R20 /MIX_4 Net-_R10-Pad2_ 100k
.end
