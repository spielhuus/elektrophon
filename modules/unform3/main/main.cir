.title KiCad schematic
C1 Net-_C1-Pad1_ GND 22n
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 220n
R1 Net-_C2-Pad2_ /BAND_PASS_200_900/IN 15k
R2 Net-_C1-Pad1_ Net-_C2-Pad2_ 15k
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_C2-Pad1_ BC846B
Q2 Net-_C2-Pad1_ Net-_Q1-Pad1_ +15V BC556B
R3 Net-_Q1-Pad2_ Net-_C1-Pad1_ 10k
R4 GND Net-_C2-Pad1_ 1.5k
C3 Net-_C2-Pad1_ /FUZZ_4/IN 100u
R5 GND /FUZZ_4/IN 10k
R8 Net-_C4-Pad1_ +15V 68k
R9 GND Net-_C4-Pad1_ 100k
R10 /BAND_PASS_200_900/IN GND 1.5k
Q3 +15V Net-_C4-Pad1_ /BAND_PASS_200_900/IN BC846B
R7 GND Net-_C4-Pad2_ 100k
R6 INPUT Net-_C4-Pad2_ 2.2k
C4 Net-_C4-Pad1_ Net-_C4-Pad2_ 1u
C5 Net-_C5-Pad1_ /BAND_PASS_200_900/IN 2.2n
C6 Net-_C6-Pad1_ Net-_C5-Pad1_ 2.2n
R12 GND Net-_C6-Pad1_ 100k
R11 Net-_C6-Pad1_ +15V 68k
R13 Net-_Q4-Pad2_ Net-_C6-Pad1_ 10k
R14 Net-_C7-Pad1_ Net-_C5-Pad1_ 4.7k
R15 GND Net-_C7-Pad1_ 1.5k
Q4 Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_C7-Pad1_ BC846B
Q5 Net-_C7-Pad1_ Net-_Q4-Pad1_ +15V BC556B
C7 Net-_C7-Pad1_ /FUZZ_1/IN 1u
R16 GND /FUZZ_1/IN 10k
C8 Net-_C8-Pad1_ GND 4.7n
C9 Net-_C10-Pad2_ Net-_C9-Pad2_ 47n
R17 Net-_C9-Pad2_ /BAND_PASS_200_900/IN 15k
R18 Net-_C8-Pad1_ Net-_C9-Pad2_ 15k
Q6 +15V Net-_Q6-Pad2_ Net-_C10-Pad2_ BC846B
R19 Net-_Q6-Pad2_ Net-_C8-Pad1_ 10k
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ 47n
C11 Net-_C11-Pad1_ Net-_C10-Pad1_ 47n
R22 GND Net-_C11-Pad1_ 100k
R21 Net-_C11-Pad1_ +15V 68k
R23 Net-_Q7-Pad2_ Net-_C11-Pad1_ 10k
R24 Net-_C12-Pad1_ Net-_C10-Pad1_ 4.7k
R25 GND Net-_C12-Pad1_ 1.5k
Q7 Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_C12-Pad1_ BC846B
Q8 Net-_C12-Pad1_ Net-_Q7-Pad1_ +15V BC556B
C12 Net-_C12-Pad1_ /FUZZ_3/IN 10u
R26 GND /FUZZ_3/IN 10k
R20 GND Net-_C10-Pad2_ 3.3k
C13 Net-_C13-Pad1_ GND 910p
C14 Net-_C14-Pad1_ Net-_C14-Pad2_ 10n
R27 Net-_C14-Pad2_ /BAND_PASS_200_900/IN 15k
R28 Net-_C13-Pad1_ Net-_C14-Pad2_ 15k
Q9 +15V Net-_Q9-Pad2_ Net-_C14-Pad1_ BC846B
R29 Net-_Q9-Pad2_ Net-_C13-Pad1_ 10k
C15 Net-_C15-Pad1_ Net-_C14-Pad1_ 10n
C16 Net-_C16-Pad1_ Net-_C15-Pad1_ 10n
R30 GND Net-_C14-Pad1_ 3.3k
R31 Net-_C16-Pad1_ +15V 68k
R33 Net-_Q10-Pad2_ Net-_C16-Pad1_ 10k
R34 Net-_C17-Pad1_ Net-_C15-Pad1_ 4.7k
R35 GND Net-_C17-Pad1_ 1.5k
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_C17-Pad1_ BC846B
Q11 Net-_C17-Pad1_ Net-_Q10-Pad1_ +15V BC556B
C17 Net-_C17-Pad1_ /FUZZ_2/IN 1u
R36 GND /FUZZ_2/IN 10k
R32 GND Net-_C16-Pad1_ 100k
R37 Net-_R37-Pad1_ Net-_C18-Pad1_ 470k
R38 Net-_C19-Pad2_ Net-_R37-Pad1_ 470k
R39 Net-_R39-Pad1_ Net-_C19-Pad1_ 100k
C18 Net-_C18-Pad1_ /FUZZ_1/IN 10n
R40 Net-_R40-Pad1_ Net-_R39-Pad1_ 100k
XRV1 Net-_R40-Pad1_ Net-_RV1-Pad2_ Net-_C20-Pad2_ voltage_divider_1
R41 Net-_D1-Pad2_ Net-_C20-Pad1_ 10k
C20 Net-_C20-Pad1_ Net-_C20-Pad2_ 470n
R42 Net-_C21-Pad2_ Net-_D1-Pad2_ 1Meg
D2 Net-_D1-Pad2_ Net-_C21-Pad2_ D1N4148
D1 Net-_C21-Pad2_ Net-_D1-Pad2_ D1N4148
R43 Net-_R43-Pad1_ Net-_C21-Pad1_ 100k
C21 Net-_C21-Pad1_ Net-_C21-Pad2_ 100n
R45 Net-_C23-Pad2_ Net-_R43-Pad1_ 220k
C23 OUT_1 Net-_C23-Pad2_ 100n
R46 GND OUT_1 1k
XU1 +5V Net-_C19-Pad2_ Net-_R37-Pad1_ Net-_RV1-Pad2_ Net-_R39-Pad1_ Net-_C21-Pad2_ Net-_D1-Pad2_ GND Net-_R43-Pad1_ Net-_C23-Pad2_ GND GND GND GND CD4069UBhex
C19 Net-_C19-Pad1_ Net-_C19-Pad2_ 100n
R44 Net-_R43-Pad1_ Net-_C22-Pad1_ 100k
C22 Net-_C22-Pad1_ Net-_C19-Pad2_ 100n
R47 Net-_R47-Pad1_ Net-_C24-Pad1_ 470k
R48 Net-_C25-Pad2_ Net-_R47-Pad1_ 470k
R49 Net-_R49-Pad1_ Net-_C25-Pad1_ 100k
C24 Net-_C24-Pad1_ /FUZZ_2/IN 10n
C25 Net-_C25-Pad1_ Net-_C25-Pad2_ 100n
R50 Net-_R50-Pad1_ Net-_R49-Pad1_ 100k
XRV2 Net-_R50-Pad1_ Net-_RV2-Pad2_ Net-_R51-Pad2_ voltage_divider_1
R51 Net-_C26-Pad2_ Net-_R51-Pad2_ 10k
C26 Net-_C26-Pad1_ Net-_C26-Pad2_ 470n
R52 Net-_C27-Pad2_ Net-_C26-Pad1_ 1Meg
D4 Net-_C26-Pad1_ Net-_C27-Pad2_ D1N4148
D3 Net-_C27-Pad2_ Net-_C26-Pad1_ D1N4148
R53 Net-_R53-Pad1_ Net-_C27-Pad1_ 100k
C27 Net-_C27-Pad1_ Net-_C27-Pad2_ 100n
R55 Net-_C29-Pad2_ Net-_R53-Pad1_ 220k
C29 OUT_2 Net-_C29-Pad2_ 100n
C28 Net-_C28-Pad1_ Net-_C25-Pad2_ 100n
R54 Net-_R53-Pad1_ Net-_C28-Pad1_ 100k
R56 GND OUT_2 1k
XU2 +5V Net-_C25-Pad2_ Net-_R47-Pad1_ Net-_RV2-Pad2_ Net-_R49-Pad1_ Net-_C27-Pad2_ Net-_C26-Pad1_ GND Net-_R53-Pad1_ Net-_C29-Pad2_ GND GND GND GND CD4069UBhex
R57 Net-_R57-Pad1_ Net-_C30-Pad1_ 470k
R58 Net-_C31-Pad2_ Net-_R57-Pad1_ 470k
R59 Net-_R59-Pad1_ Net-_C31-Pad1_ 100k
C31 Net-_C31-Pad1_ Net-_C31-Pad2_ 100n
R60 Net-_R60-Pad1_ Net-_R59-Pad1_ 100k
XRV3 Net-_R60-Pad1_ Net-_RV3-Pad2_ Net-_R61-Pad2_ voltage_divider_1
R61 Net-_C32-Pad2_ Net-_R61-Pad2_ 10k
C32 Net-_C32-Pad1_ Net-_C32-Pad2_ 470n
R62 Net-_C33-Pad2_ Net-_C32-Pad1_ 1Meg
D6 Net-_C32-Pad1_ Net-_C33-Pad2_ D1N4148
D5 Net-_C33-Pad2_ Net-_C32-Pad1_ D1N4148
R63 Net-_R63-Pad1_ Net-_C33-Pad1_ 100k
C33 Net-_C33-Pad1_ Net-_C33-Pad2_ 100n
R65 Net-_C35-Pad2_ Net-_R63-Pad1_ 220k
C35 OUT_3 Net-_C35-Pad2_ 100n
C34 Net-_C34-Pad1_ Net-_C31-Pad2_ 100n
R64 Net-_R63-Pad1_ Net-_C34-Pad1_ 100k
R66 GND OUT_3 1k
XU3 +5V Net-_C31-Pad2_ Net-_R57-Pad1_ Net-_RV3-Pad2_ Net-_R59-Pad1_ Net-_C33-Pad2_ Net-_C32-Pad1_ GND Net-_R63-Pad1_ Net-_C35-Pad2_ GND GND /FUZZ_3/IN Net-_C30-Pad2_ CD4069UBhex
C30 Net-_C30-Pad1_ Net-_C30-Pad2_ 10n
R77 Net-_C30-Pad2_ /FUZZ_3/IN 1Meg
R67 Net-_R67-Pad1_ Net-_C36-Pad1_ 470k
R68 Net-_C37-Pad2_ Net-_R67-Pad1_ 470k
R69 Net-_R69-Pad1_ Net-_C37-Pad1_ 100k
C36 Net-_C36-Pad1_ /FUZZ_4/IN 10n
C37 Net-_C37-Pad1_ Net-_C37-Pad2_ 100n
R70 Net-_R70-Pad1_ Net-_R69-Pad1_ 100k
XRV4 Net-_R70-Pad1_ Net-_RV4-Pad2_ Net-_R71-Pad2_ voltage_divider_1
R72 Net-_C39-Pad2_ Net-_C38-Pad1_ 1Meg
D8 Net-_C38-Pad1_ Net-_C39-Pad2_ D1N4148
D7 Net-_C39-Pad2_ Net-_C38-Pad1_ D1N4148
R73 Net-_R73-Pad1_ Net-_C39-Pad1_ 100k
C39 Net-_C39-Pad1_ Net-_C39-Pad2_ 100n
R75 Net-_C41-Pad2_ Net-_R73-Pad1_ 220k
C41 OUT_4 Net-_C41-Pad2_ 100n
R76 GND OUT_4 1k
XU4 +5V Net-_C37-Pad2_ Net-_R67-Pad1_ Net-_RV4-Pad2_ Net-_R69-Pad1_ Net-_C39-Pad2_ Net-_C38-Pad1_ GND Net-_R73-Pad1_ Net-_C41-Pad2_ GND GND GND GND CD4069UBhex
R74 Net-_R73-Pad1_ Net-_C40-Pad1_ 100k
C40 Net-_C40-Pad1_ Net-_C37-Pad2_ 100n
C38 Net-_C38-Pad1_ Net-_C38-Pad2_ 470n
R71 Net-_C38-Pad2_ Net-_R71-Pad2_ 10k
.end
