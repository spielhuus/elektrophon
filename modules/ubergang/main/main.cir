.title KiCad schematic
R6 Net-_R4-Pad2_ GND 10k
R4 Net-_R3-Pad2_ Net-_R4-Pad2_ 47k
R3 Net-_R2-Pad2_ Net-_R3-Pad2_ 47k
R2 Net-_R1-Pad2_ Net-_R2-Pad2_ 47k
R1 +15V Net-_R1-Pad2_ 520k
R7 Net-_R12-Pad2_ CV_S 47k
R8 Net-_R13-Pad2_ CV_S 47k
R9 Net-_R14-Pad2_ CV_S 47k
R10 Net-_R10-Pad1_ CV_S 47k
R13 Net-_Q4-Pad2_ Net-_R13-Pad2_ 1meg
R14 Net-_Q2-Pad2_ Net-_R14-Pad2_ 1meg
R15 Net-_Q3-Pad2_ Net-_R10-Pad1_ 1meg
R12 Net-_Q1-Pad2_ Net-_R12-Pad2_ 1meg
XU5 Net-_Q4-Pad3_ NC_01 IN_2_S GND Net-_R26-Pad2_ -15V NC_02 NC_03 NC_04 NC_05 +15V Net-_R25-Pad2_ GND IN_1_S NC_06 Net-_Q1-Pad3_ LM13700d
XU6 Net-_Q3-Pad3_ NC_07 IN_4_S GND Net-_R28-Pad2_ -15V NC_08 NC_09 NC_10 NC_11 +15V Net-_R27-Pad2_ GND IN_3_S NC_12 Net-_Q2-Pad3_ LM13700d
Q4 Net-_Q4-Pad3_ Net-_Q4-Pad2_ Net-_Q4-Pad1_ BC556B
Q3 Net-_Q3-Pad3_ Net-_Q3-Pad2_ Net-_Q3-Pad1_ BC556B
Q2 Net-_Q2-Pad3_ Net-_Q2-Pad2_ Net-_Q2-Pad1_ BC556B
R27 Net-_R25-Pad1_ Net-_R27-Pad2_ 100k
R26 Net-_R25-Pad1_ Net-_R26-Pad2_ 100k
R25 Net-_R25-Pad1_ Net-_R25-Pad2_ 100k
R28 Net-_R25-Pad1_ Net-_R28-Pad2_ 100k
XU1 Net-_R1-Pad2_ Net-_R12-Pad2_ +15V GND Net-_Q1-Pad2_ LT1014x_30V
XU2 Net-_R2-Pad2_ Net-_R13-Pad2_ +15V GND Net-_Q4-Pad2_ LT1014x_30V
XU3 Net-_R3-Pad2_ Net-_R14-Pad2_ +15V GND Net-_Q2-Pad2_ LT1014x_30V
XU4 Net-_R4-Pad2_ Net-_R10-Pad1_ +15V GND Net-_Q3-Pad2_ LT1014x_30V
Q1 Net-_Q1-Pad3_ Net-_Q1-Pad2_ Net-_Q1-Pad1_ BC556B
XU11 CV_S CV_S CV_IN -15V GND Net-_R25-Pad1_ OUT +15V TL072c
XU7 Net-_R11-Pad2_ Net-_R11-Pad2_ IN_1 -15V IN_2 Net-_R16-Pad2_ Net-_R16-Pad2_ +15V TL072c
XU9 Net-_R20-Pad2_ Net-_R20-Pad2_ IN_3 -15V IN_4 Net-_R21-Pad2_ Net-_R21-Pad2_ +15V TL072c
R11 IN_1_S Net-_R11-Pad2_ 100k
R22 IN_1_S GND 220
R16 IN_2_S Net-_R16-Pad2_ 100k
R23 IN_2_S GND 220
R20 IN_3_S Net-_R20-Pad2_ 100k
R24 IN_3_S GND 220
R21 IN_4_S Net-_R21-Pad2_ 100k
R29 IN_4_S GND 220
R30 OUT Net-_R25-Pad1_ 100k
R19 Net-_Q2-Pad2_ Net-_Q3-Pad1_ 33k
R18 Net-_Q4-Pad2_ Net-_Q2-Pad1_ 33k
R17 Net-_Q1-Pad2_ Net-_Q4-Pad1_ 33k
R5 Net-_D1-Pad1_ Net-_Q1-Pad1_ 33k
D1 Net-_D1-Pad2_ Net-_D1-Pad1_ D1N4148
D2 +15V Net-_D1-Pad2_ D1N4148
.end
