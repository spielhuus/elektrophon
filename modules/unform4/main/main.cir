.title KiCad schematic
C1 Net-_C1-Pad1_ GND 22n
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 220n
R1 Net-_C2-Pad2_ /BAND_PASS_200_900/IN 15k
R2 Net-_C1-Pad1_ Net-_C2-Pad2_ 15k
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_C2-Pad1_ BC846B
Q2 Net-_C2-Pad1_ Net-_Q1-Pad1_ +15V BC556B
R3 Net-_Q1-Pad2_ Net-_C1-Pad1_ 10k
R4 GND Net-_C2-Pad1_ 1.5k
C3 Net-_C2-Pad1_ /FUZZ_4/IN 100u
R5 GND /FUZZ_4/IN 10k
R8 Net-_C4-Pad1_ +15V 68k
R9 GND Net-_C4-Pad1_ 100k
R10 /BAND_PASS_200_900/IN GND 1.5k
Q3 +15V Net-_C4-Pad1_ /BAND_PASS_200_900/IN BC846B
R7 GND Net-_C4-Pad2_ 100k
R6 INPUT Net-_C4-Pad2_ 2.2k
C4 Net-_C4-Pad1_ Net-_C4-Pad2_ 1u
C5 Net-_C5-Pad1_ /BAND_PASS_200_900/IN 2.2n
C6 Net-_C6-Pad1_ Net-_C5-Pad1_ 2.2n
R12 GND Net-_C6-Pad1_ 100k
R11 Net-_C6-Pad1_ +15V 68k
R13 Net-_Q4-Pad2_ Net-_C6-Pad1_ 10k
R14 Net-_C7-Pad1_ Net-_C5-Pad1_ 4.7k
R15 GND Net-_C7-Pad1_ 1.5k
Q4 Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_C7-Pad1_ BC846B
Q5 Net-_C7-Pad1_ Net-_Q4-Pad1_ +15V BC556B
C7 Net-_C7-Pad1_ /FUZZ_1/IN 1u
R16 GND /FUZZ_1/IN 10k
C8 Net-_C8-Pad1_ GND 4.7n
C9 Net-_C10-Pad2_ Net-_C9-Pad2_ 47n
R17 Net-_C9-Pad2_ /BAND_PASS_200_900/IN 15k
R18 Net-_C8-Pad1_ Net-_C9-Pad2_ 15k
Q6 +15V Net-_Q6-Pad2_ Net-_C10-Pad2_ BC846B
R19 Net-_Q6-Pad2_ Net-_C8-Pad1_ 10k
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ 47n
C11 Net-_C11-Pad1_ Net-_C10-Pad1_ 47n
R22 GND Net-_C11-Pad1_ 100k
R21 Net-_C11-Pad1_ +15V 68k
R23 Net-_Q7-Pad2_ Net-_C11-Pad1_ 10k
R24 Net-_C12-Pad1_ Net-_C10-Pad1_ 4.7k
R25 GND Net-_C12-Pad1_ 1.5k
Q7 Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_C12-Pad1_ BC846B
Q8 Net-_C12-Pad1_ Net-_Q7-Pad1_ +15V BC556B
C12 Net-_C12-Pad1_ /FUZZ_3/IN 10u
R26 GND /FUZZ_3/IN 10k
R20 GND Net-_C10-Pad2_ 3.3k
C13 Net-_C13-Pad1_ GND 910p
C14 Net-_C14-Pad1_ Net-_C14-Pad2_ 10n
R27 Net-_C14-Pad2_ /BAND_PASS_200_900/IN 15k
R28 Net-_C13-Pad1_ Net-_C14-Pad2_ 15k
Q9 +15V Net-_Q9-Pad2_ Net-_C14-Pad1_ BC846B
R29 Net-_Q9-Pad2_ Net-_C13-Pad1_ 10k
C15 Net-_C15-Pad1_ Net-_C14-Pad1_ 10n
C16 Net-_C16-Pad1_ Net-_C15-Pad1_ 10n
R30 GND Net-_C14-Pad1_ 3.3k
R31 Net-_C16-Pad1_ +15V 68k
R33 Net-_Q10-Pad2_ Net-_C16-Pad1_ 10k
R34 Net-_C17-Pad1_ Net-_C15-Pad1_ 4.7k
R35 GND Net-_C17-Pad1_ 1.5k
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_C17-Pad1_ BC846B
Q11 Net-_C17-Pad1_ Net-_Q10-Pad1_ +15V BC556B
C17 Net-_C17-Pad1_ /FUZZ_2/IN 1u
R36 GND /FUZZ_2/IN 10k
R32 GND Net-_C16-Pad1_ 100k
R37 Net-_C18-Pad1_ GND 470k
C19 Net-_C19-Pad1_ Net-_C18-Pad1_ 1n
R39 +15V Net-_C19-Pad1_ 22k
R43 Net-_C21-Pad1_ Net-_Q13-Pad1_ 47k
C18 Net-_C18-Pad1_ /FUZZ_1/IN 10u
XRV1 Net-_Q13-Pad1_ Net-_C22-Pad1_ OUT_1 voltage_divider_2
R38 Net-_C19-Pad1_ Net-_C18-Pad1_ 2.2Meg
C23 Net-_C23-Pad1_ Net-_C19-Pad1_ 47n
R42 Net-_Q13-Pad1_ Net-_C23-Pad1_ 1.2Meg
C22 Net-_C22-Pad1_ Net-_C19-Pad1_ 2.2n
R41 Net-_C21-Pad1_ +15V 100k
C21 Net-_C21-Pad1_ +15V 47n
C24 GND Net-_C24-Pad2_ 10u
R44 Net-_C24-Pad2_ GND 1.5k
C20 GND Net-_C20-Pad2_ 10u
R40 Net-_C20-Pad2_ GND 1k
Q12 Net-_C19-Pad1_ Net-_C18-Pad1_ Net-_C20-Pad2_ BC846B
Q13 Net-_Q13-Pad1_ Net-_C23-Pad1_ Net-_C24-Pad2_ BC846B
R45 Net-_C25-Pad1_ GND 470k
C26 Net-_C26-Pad1_ Net-_C25-Pad1_ 1n
R47 +15V Net-_C26-Pad1_ 22k
R51 Net-_C28-Pad1_ Net-_Q15-Pad1_ 47k
C25 Net-_C25-Pad1_ /FUZZ_2/IN 10u
XRV2 Net-_Q15-Pad1_ Net-_C29-Pad1_ OUT_2 voltage_divider_2
R46 Net-_C26-Pad1_ Net-_C25-Pad1_ 2.2Meg
C30 Net-_C30-Pad1_ Net-_C26-Pad1_ 47n
R50 Net-_Q15-Pad1_ Net-_C30-Pad1_ 1.2Meg
C29 Net-_C29-Pad1_ Net-_C26-Pad1_ 2.2n
R49 Net-_C28-Pad1_ +15V 100k
C28 Net-_C28-Pad1_ +15V 47n
C31 GND Net-_C31-Pad2_ 10u
R52 Net-_C31-Pad2_ GND 1.5k
C27 GND Net-_C27-Pad2_ 10u
R48 Net-_C27-Pad2_ GND 1k
Q15 Net-_Q15-Pad1_ Net-_C30-Pad1_ Net-_C31-Pad2_ BC846B
Q14 Net-_C26-Pad1_ Net-_C25-Pad1_ Net-_C27-Pad2_ BC846B
R53 Net-_C32-Pad1_ GND 470k
C33 Net-_C33-Pad1_ Net-_C32-Pad1_ 1n
R55 +15V Net-_C33-Pad1_ 22k
R59 Net-_C35-Pad1_ Net-_Q17-Pad1_ 47k
C32 Net-_C32-Pad1_ /FUZZ_3/IN 10u
XRV3 Net-_Q17-Pad1_ Net-_C36-Pad1_ OUT_3 voltage_divider_2
R54 Net-_C33-Pad1_ Net-_C32-Pad1_ 2.2Meg
C37 Net-_C37-Pad1_ Net-_C33-Pad1_ 47n
R58 Net-_Q17-Pad1_ Net-_C37-Pad1_ 1.2Meg
C36 Net-_C36-Pad1_ Net-_C33-Pad1_ 2.2n
R57 Net-_C35-Pad1_ +15V 100k
C35 Net-_C35-Pad1_ +15V 47n
C38 GND Net-_C38-Pad2_ 10u
R60 Net-_C38-Pad2_ GND 1.5k
C34 GND Net-_C34-Pad2_ 10u
R56 Net-_C34-Pad2_ GND 1k
Q16 Net-_C33-Pad1_ Net-_C32-Pad1_ Net-_C34-Pad2_ BC846B
Q17 Net-_Q17-Pad1_ Net-_C37-Pad1_ Net-_C38-Pad2_ BC846B
R61 Net-_C39-Pad1_ GND 470k
C40 Net-_C40-Pad1_ Net-_C39-Pad1_ 1n
R63 +15V Net-_C40-Pad1_ 22k
R67 Net-_C42-Pad1_ Net-_Q19-Pad1_ 47k
C39 Net-_C39-Pad1_ /FUZZ_4/IN 10u
XRV4 Net-_Q19-Pad1_ Net-_C43-Pad1_ OUT_4 voltage_divider_2
R62 Net-_C40-Pad1_ Net-_C39-Pad1_ 2.2Meg
C44 Net-_C44-Pad1_ Net-_C40-Pad1_ 47n
R66 Net-_Q19-Pad1_ Net-_C44-Pad1_ 1.2Meg
C43 Net-_C43-Pad1_ Net-_C40-Pad1_ 2.2n
R65 Net-_C42-Pad1_ +15V 100k
C42 Net-_C42-Pad1_ +15V 47n
C45 GND Net-_C45-Pad2_ 10u
R68 Net-_C45-Pad2_ GND 1.5k
C41 GND Net-_C41-Pad2_ 10u
R64 Net-_C41-Pad2_ GND 1k
Q19 Net-_Q19-Pad1_ Net-_C44-Pad1_ Net-_C45-Pad2_ BC846B
Q18 Net-_C40-Pad1_ Net-_C39-Pad1_ Net-_C41-Pad2_ BC846B
.end
