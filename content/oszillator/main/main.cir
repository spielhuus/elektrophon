.title KiCad schematic
XU3 outi Net-_C2-Pad2_ GND -15V NC_01 NC_02 NC_03 +15V TL072c
XU2 Net-_R5-Pad2_ Net-_C1-Pad1_ Net-_R1-Pad1_ -15V Net-_R10-Pad1_ Net-_R13-Pad2_ SAW +15V TL072c
R4 Net-_C2-Pad2_ /cv 270k
C2 outi Net-_C2-Pad2_ 1n
R10 Net-_R10-Pad1_ outi 10k
R13 SAW Net-_R13-Pad2_ 120k
R9 Net-_R13-Pad2_ GND 33k
R2 GND Net-_C1-Pad1_ 4.7k
XU5 MES Net-_R12-Pad2_ GND -15V GND Net-_D1-Pad1_ Net-_D1-Pad2_ +15V TL072c
R5 Net-_Q1-Pad2_ Net-_R5-Pad2_ 22k
R14 Net-_D1-Pad1_ SAW 100k
R17 Net-_D2-Pad2_ Net-_D1-Pad1_ 100k
D2 Net-_D1-Pad2_ Net-_D2-Pad2_ D1N4148
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ D1N4148
XU7 TRI Net-_C5-Pad2_ GND -15V Net-_Q3-Pad3_ Net-_Q2-Pad3_ SINE +15V TL072c
C5 TRI Net-_C5-Pad2_ 22p
R24 TRI Net-_C5-Pad2_ 200k
R22 Net-_C5-Pad2_ Net-_D2-Pad2_ 50k
R21 Net-_C5-Pad2_ SAW 100k
R20 Net-_C5-Pad2_ Net-_R20-Pad2_ 220k
XRV2 -15V Net-_R20-Pad2_ GND TRI_OFFSET
R32 SINE Net-_Q2-Pad3_ 17k
R31 GND Net-_Q3-Pad3_ 17k
R30 GND Net-_Q3-Pad2_ 2.2k
R29 Net-_Q3-Pad3_ +15V 10k
R26 Net-_Q2-Pad3_ +15V 10k
XRV3 Net-_Q2-Pad2_ TRI NC_04 SINE_ROUND
R25 GND Net-_Q2-Pad2_ 2k2
R27 Net-_Q3-Pad1_ Net-_Q2-Pad1_ 390
XRV4 Net-_Q2-Pad1_ Net-_R28-Pad2_ Net-_Q3-Pad1_ SINE_SIM
R28 -15V Net-_R28-Pad2_ 18k
Q2 Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ BC846B
Q3 Net-_Q3-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ BC846B
R1 Net-_R1-Pad1_ -15V 22k
R3 GND Net-_R1-Pad1_ 10k
C1 Net-_C1-Pad1_ /pulse 270p
JQ1 outi Net-_Q1-Pad2_ Net-_C2-Pad2_ J2N5459
R11 Net-_R10-Pad1_ Net-_R11-Pad2_ 47k
XRV1 +15V Net-_R11-Pad2_ GND SAW_OFFSET
R8 Net-_R12-Pad2_ outi 100k
R12 MES Net-_R12-Pad2_ 100k
XU6 Net-_R18-Pad1_ Net-_R15-Pad1_ GND -15V GND Net-_R19-Pad1_ /cv +15V TL072c
R15 Net-_R15-Pad1_ /DAC_B 100k
R16 Net-_R15-Pad1_ /DAC_A 100k
R18 Net-_R18-Pad1_ Net-_R15-Pad1_ 100k
R19 Net-_R19-Pad1_ Net-_R18-Pad1_ 100k
R23 /cv Net-_R19-Pad1_ 100k
.end
