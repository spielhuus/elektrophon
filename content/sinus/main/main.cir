.title KiCad schematic
XU3 Net-_Q1-Pad2_ Net-_R17-Pad1_ GND -15V GND Net-_C6-Pad2_ -5V +15V TL072c
XU2 +5V Net-_C5-Pad2_ Net-_C4-Pad1_ -15V /core/OUTb /core/OUTa Net-_C3-Pad2_ +15V TL072c
R4 GND /core/OUTb 100k
XJ2 GND Net-_J2-PadT_ NC_01 OUT
R7 Net-_C3-Pad2_ Net-_J2-PadT_ 100
R3 /core/OUTb +15V 51k
R5 /core/OUTa +15V 51k
R6 /core/OUTa Net-_C3-Pad2_ 100k
C3 /core/OUTa Net-_C3-Pad2_ 47p
XU4 Net-_C9-Pad2_ Net-_C9-Pad1_ GND -15V GND Net-_C8-Pad1_ /core/IN +15V TL072c
XU1 Net-_R27-Pad1_ Net-_U1-Pad12_ Net-_R14-Pad1_ Net-_R20-Pad2_ Net-_C8-Pad1_ -15V NC_02 NC_03 NC_04 NC_05 +15V Net-_U1-Pad12_ GND Net-_R19-Pad1_ Net-_R19-Pad1_ Net-_C7-Pad2_ LM13700d
XU5 Net-_Q11-Pad2_ Net-_Q27-Pad3_ Net-_R31-Pad1_ -15V GND Net-_R54-Pad1_ Net-_Q30-Pad2_ +15V TL072c
R9 Net-_C4-Pad1_ Net-_R8-Pad1_ 100k
C4 Net-_C4-Pad1_ GND 22u
R12 Net-_C6-Pad2_ +5V 100k
R8 Net-_R8-Pad1_ +15V 10k
R11 +5V Net-_C5-Pad2_ 100k
C5 +5V Net-_C5-Pad2_ 22u
R10 GND Net-_C5-Pad2_ 100k
R13 -5V Net-_C6-Pad2_ 100k
C6 -5V Net-_C6-Pad2_ 22u
XU7 Net-_R8-Pad1_ GND Net-_R8-Pad1_ TL431
R22 Net-_C8-Pad1_ Net-_R15-Pad1_ 100k
R15 Net-_R15-Pad1_ Net-_R15-Pad2_ 820k
XRV5 +5V Net-_R26-Pad1_ -5V TRIM
R28 GND Net-_Q1-Pad1_ 22k
Q2 Net-_Q2-Pad3_ Net-_Q1-Pad2_ Net-_Q1-Pad1_ BC556B
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad2_ BC556B
R25 Net-_Q1-Pad1_ Net-_R17-Pad1_ 51k
R17 Net-_R17-Pad1_ Net-_R17-Pad2_ 100k
R26 Net-_R26-Pad1_ Net-_R20-Pad2_ 3M
R29 /core/IN Net-_C8-Pad1_ 100k
C8 Net-_C8-Pad1_ /core/IN 47p
R23 GND Net-_R20-Pad2_ 10k
R20 GND Net-_R20-Pad2_ 100k
R16 GND Net-_R14-Pad1_ 10k
R14 Net-_R14-Pad1_ Net-_J4-PadT_ 100k
XJ4 GND Net-_J4-PadT_ NC_06 IN
R27 Net-_R27-Pad1_ Net-_Q2-Pad3_ 10k
XRV1 +5V Net-_R15-Pad2_ -5V POT
XRV2 +5V Net-_R17-Pad2_ GND POT
R19 Net-_R19-Pad1_ +5V 51k
R24 Net-_C7-Pad2_ +5V 100k
C7 -15V Net-_C7-Pad2_ 10u
R21 Net-_C8-Pad1_ Net-_R21-Pad2_ 100k
XJ5 GND Net-_J5-PadT_ NC_07 LEVEL
XRV3 Net-_J5-PadT_ Net-_R21-Pad2_ GND POT
XRV4 Net-_J3-PadT_ Net-_R18-Pad2_ GND POT
XJ3 GND Net-_J3-PadT_ NC_08 CV
R18 Net-_R17-Pad1_ Net-_R18-Pad2_ 100k
Q14 /core/OUTa Net-_Q14-Pad2_ Net-_Q12-Pad3_ BC846B
R45 Net-_Q14-Pad2_ Net-_Q16-Pad2_ 750
Q15 Net-_Q14-Pad2_ Net-_Q11-Pad2_ Net-_Q15-Pad3_ BC556B
R44 Net-_Q15-Pad3_ +15V 51k
Q16 /core/OUTb Net-_Q16-Pad2_ Net-_Q12-Pad3_ BC846B
R47 Net-_Q16-Pad2_ Net-_Q18-Pad2_ 750
Q17 Net-_Q16-Pad2_ Net-_Q11-Pad2_ Net-_Q17-Pad3_ BC556B
R46 Net-_Q17-Pad3_ +15V 51k
Q18 /core/OUTa Net-_Q18-Pad2_ Net-_Q12-Pad3_ BC846B
R49 Net-_Q18-Pad2_ Net-_Q20-Pad2_ 750
Q19 Net-_Q18-Pad2_ Net-_Q11-Pad2_ Net-_Q19-Pad3_ BC556B
R48 Net-_Q19-Pad3_ +15V 51k
Q20 /core/OUTb Net-_Q20-Pad2_ Net-_Q12-Pad3_ BC846B
R51 Net-_Q20-Pad2_ Net-_Q22-Pad2_ 750
Q21 Net-_Q20-Pad2_ Net-_Q11-Pad2_ Net-_Q21-Pad3_ BC556B
R50 Net-_Q21-Pad3_ +15V 51k
Q22 /core/OUTa Net-_Q22-Pad2_ Net-_Q12-Pad3_ BC846B
R53 Net-_Q22-Pad2_ Net-_Q24-Pad2_ 750
Q23 Net-_Q22-Pad2_ Net-_Q11-Pad2_ Net-_Q23-Pad3_ BC556B
R52 Net-_Q23-Pad3_ +15V 51k
Q24 /core/OUTb Net-_Q24-Pad2_ Net-_Q12-Pad3_ BC846B
R56 Net-_Q24-Pad2_ Net-_Q26-Pad2_ 750
Q25 Net-_Q24-Pad2_ Net-_Q11-Pad2_ Net-_Q25-Pad3_ BC556B
R55 Net-_Q25-Pad3_ +15V 51k
Q26 /core/OUTa Net-_Q26-Pad2_ Net-_Q12-Pad3_ BC846B
R59 Net-_Q26-Pad2_ Net-_Q28-Pad2_ 750
Q27 Net-_Q26-Pad2_ Net-_Q11-Pad2_ Net-_Q27-Pad3_ BC556B
R58 Net-_Q27-Pad3_ +15V 51k
Q12 /core/OUTb Net-_Q11-Pad1_ Net-_Q12-Pad3_ BC846B
R41 Net-_Q11-Pad1_ Net-_Q8-Pad1_ 750
Q11 Net-_Q11-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ BC556B
R42 Net-_Q11-Pad3_ +15V 51k
R43 Net-_Q14-Pad2_ Net-_Q11-Pad1_ 750
Q9 /core/OUTa Net-_Q8-Pad1_ Net-_Q12-Pad3_ BC846B
R38 Net-_Q8-Pad1_ Net-_Q6-Pad1_ 750
Q8 Net-_Q8-Pad1_ Net-_Q11-Pad2_ Net-_Q8-Pad3_ BC556B
R39 Net-_Q8-Pad3_ +15V 51k
Q7 /core/OUTb Net-_Q6-Pad1_ Net-_Q12-Pad3_ BC846B
R36 Net-_Q6-Pad1_ Net-_Q4-Pad1_ 750
Q6 Net-_Q6-Pad1_ Net-_Q11-Pad2_ Net-_Q6-Pad3_ BC556B
R37 Net-_Q6-Pad3_ +15V 51k
Q5 /core/OUTa Net-_Q4-Pad1_ Net-_Q12-Pad3_ BC846B
R32 Net-_Q4-Pad1_ /core/IN 750
Q4 Net-_Q4-Pad1_ Net-_Q11-Pad2_ Net-_Q4-Pad3_ BC556B
R34 Net-_Q4-Pad3_ +15V 51k
Q3 /core/OUTb /core/IN Net-_Q12-Pad3_ BC846B
Q28 /core/OUTb Net-_Q28-Pad2_ Net-_Q12-Pad3_ BC846B
R61 Net-_Q28-Pad2_ Net-_Q30-Pad2_ 750
Q29 Net-_Q28-Pad2_ Net-_Q11-Pad2_ Net-_Q29-Pad3_ BC556B
R60 Net-_Q29-Pad3_ +15V 51k
Q30 /core/OUTa Net-_Q30-Pad2_ Net-_Q12-Pad3_ BC846B
R57 Net-_Q30-Pad2_ Net-_R54-Pad1_ 10k
R54 Net-_R54-Pad1_ /core/IN 10k
XU8 +15V Net-_R31-Pad1_ Net-_R30-Pad1_ TL431
R30 Net-_R30-Pad1_ +15V 10k
R31 Net-_R31-Pad1_ Net-_R30-Pad1_ 10k
R33 -15V Net-_R31-Pad1_ 10k
C10 +15V GND 0.1u
Q10 Net-_C9-Pad1_ GND Net-_D1-Pad2_ BC846B
Q13 Net-_Q12-Pad3_ GND Net-_D1-Pad2_ BC846B
D1 Net-_C9-Pad1_ Net-_D1-Pad2_ D1N4148
R40 Net-_C9-Pad2_ Net-_D1-Pad2_ 1k
C9 Net-_C9-Pad1_ Net-_C9-Pad2_ 47p
R35 +5V Net-_C9-Pad1_ 36k
.end
