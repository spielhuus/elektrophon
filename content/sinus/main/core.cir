.title KiCad schematic
Q12 /OUTa Net-_Q12-Pad2_ Net-_Q1-Pad3_ BC846B
R16 Net-_Q12-Pad2_ Net-_Q14-Pad2_ 750
Q13 Net-_Q12-Pad2_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ BC556B
R15 Net-_Q13-Pad3_ +15V 51k
Q14 /OUTb Net-_Q14-Pad2_ Net-_Q1-Pad3_ BC846B
R18 Net-_Q14-Pad2_ Net-_Q16-Pad2_ 750
Q15 Net-_Q14-Pad2_ Net-_Q13-Pad2_ Net-_Q15-Pad3_ BC556B
R17 Net-_Q15-Pad3_ +15V 51k
Q16 /OUTa Net-_Q16-Pad2_ Net-_Q1-Pad3_ BC846B
R20 Net-_Q16-Pad2_ Net-_Q18-Pad2_ 750
Q17 Net-_Q16-Pad2_ Net-_Q13-Pad2_ Net-_Q17-Pad3_ BC556B
R19 Net-_Q17-Pad3_ +15V 51k
Q18 /OUTb Net-_Q18-Pad2_ Net-_Q1-Pad3_ BC846B
R22 Net-_Q18-Pad2_ Net-_Q20-Pad2_ 750
Q19 Net-_Q18-Pad2_ Net-_Q13-Pad2_ Net-_Q19-Pad3_ BC556B
R21 Net-_Q19-Pad3_ +15V 51k
Q20 /OUTa Net-_Q20-Pad2_ Net-_Q1-Pad3_ BC846B
R24 Net-_Q20-Pad2_ Net-_Q22-Pad2_ 750
Q21 Net-_Q20-Pad2_ Net-_Q13-Pad2_ Net-_Q21-Pad3_ BC556B
R23 Net-_Q21-Pad3_ +15V 51k
Q22 /OUTb Net-_Q22-Pad2_ Net-_Q1-Pad3_ BC846B
R27 Net-_Q22-Pad2_ Net-_Q24-Pad2_ 750
Q23 Net-_Q22-Pad2_ Net-_Q13-Pad2_ Net-_Q23-Pad3_ BC556B
R26 Net-_Q23-Pad3_ +15V 51k
Q24 /OUTa Net-_Q24-Pad2_ Net-_Q1-Pad3_ BC846B
R30 Net-_Q24-Pad2_ Net-_Q26-Pad2_ 750
Q25 Net-_Q24-Pad2_ Net-_Q13-Pad2_ Net-_Q25-Pad3_ BC556B
R29 Net-_Q25-Pad3_ +15V 51k
Q10 /OUTb Net-_Q10-Pad2_ Net-_Q1-Pad3_ BC846B
R12 Net-_Q10-Pad2_ Net-_Q6-Pad1_ 750
Q9 Net-_Q10-Pad2_ Net-_Q13-Pad2_ Net-_Q9-Pad3_ BC556B
R13 Net-_Q9-Pad3_ +15V 51k
R14 Net-_Q12-Pad2_ Net-_Q10-Pad2_ 750
Q7 /OUTa Net-_Q6-Pad1_ Net-_Q1-Pad3_ BC846B
R9 Net-_Q6-Pad1_ Net-_Q4-Pad1_ 750
Q6 Net-_Q6-Pad1_ Net-_Q13-Pad2_ Net-_Q6-Pad3_ BC556B
R10 Net-_Q6-Pad3_ +15V 51k
Q5 /OUTb Net-_Q4-Pad1_ Net-_Q1-Pad3_ BC846B
R7 Net-_Q4-Pad1_ Net-_Q2-Pad1_ 750
Q4 Net-_Q4-Pad1_ Net-_Q13-Pad2_ Net-_Q4-Pad3_ BC556B
R8 Net-_Q4-Pad3_ +15V 51k
Q3 /OUTa Net-_Q2-Pad1_ Net-_Q1-Pad3_ BC846B
R3 Net-_Q2-Pad1_ /IN 750
Q2 Net-_Q2-Pad1_ Net-_Q13-Pad2_ Net-_Q2-Pad3_ BC556B
R5 Net-_Q2-Pad3_ +15V 51k
Q1 /OUTb /IN Net-_Q1-Pad3_ BC846B
Q26 /OUTb Net-_Q26-Pad2_ Net-_Q1-Pad3_ BC846B
R32 Net-_Q26-Pad2_ Net-_Q28-Pad2_ 750
Q27 Net-_Q26-Pad2_ Net-_Q13-Pad2_ Net-_Q27-Pad3_ BC556B
R31 Net-_Q27-Pad3_ +15V 51k
Q28 /OUTa Net-_Q28-Pad2_ Net-_Q1-Pad3_ BC846B
R28 Net-_Q28-Pad2_ Net-_R25-Pad1_ 10k
R25 Net-_R25-Pad1_ /IN 10k
XU1 +15V Net-_R2-Pad1_ Net-_R1-Pad1_ TL431
R1 Net-_R1-Pad1_ +15V 10k
R2 Net-_R2-Pad1_ Net-_R1-Pad1_ 10k
R4 -15V Net-_R2-Pad1_ 10k
XU3 Net-_Q13-Pad2_ Net-_Q25-Pad3_ Net-_R2-Pad1_ -15V NC_01 NC_02 NC_03 +15V TL072c
C2 +15V GND 0.1u
Q8 Net-_C1-Pad1_ GND Net-_D1-Pad2_ BC846B
Q11 Net-_Q1-Pad3_ GND Net-_D1-Pad2_ BC846B
D1 Net-_C1-Pad1_ Net-_D1-Pad2_ D1N4148
R11 Net-_C1-Pad2_ Net-_D1-Pad2_ 1k
XU2 Net-_C1-Pad2_ Net-_C1-Pad1_ GND -15V GND Net-_R25-Pad1_ Net-_Q28-Pad2_ +15V TL072c
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 47p
R6 +5V Net-_C1-Pad1_ 36k
.end
