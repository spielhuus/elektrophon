.title KiCad schematic
XU7 +15V Net-_R31-Pad2_ Net-_R30-Pad2_ TL431
D1 Net-_D1-Pad2_ Net-_C9-Pad1_ D1N4148
XQ7 GND Net-_Q6-Pad3_ /OUTb Net-_Q10-Pad4_ Net-_D1-Pad2_ Net-_C9-Pad1_ PMP4201
XQ3 /IN Net-_Q3-Pad2_ /OUTa Net-_Q10-Pad4_ Net-_Q10-Pad4_ /OUTb PMP4201
XQ5 Net-_Q4-Pad3_ Net-_Q5-Pad2_ /OUTa Net-_Q10-Pad4_ Net-_Q10-Pad4_ /OUTb PMP4201
XQ8 GND Net-_Q8-Pad2_ /OUTa Net-_Q10-Pad4_ Net-_D1-Pad2_ Net-_Q10-Pad4_ PMP4201
XQ10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ /OUTa Net-_Q10-Pad4_ Net-_Q10-Pad4_ /OUTb PMP4201
XQ12 Net-_Q11-Pad3_ Net-_Q12-Pad2_ /OUTa Net-_Q10-Pad4_ Net-_Q10-Pad4_ /OUTb PMP4201
XQ14 Net-_Q13-Pad3_ Net-_Q14-Pad2_ /OUTa Net-_Q10-Pad4_ Net-_Q10-Pad4_ /OUTb PMP4201
XQ16 Net-_Q15-Pad3_ Net-_Q16-Pad2_ /OUTa Net-_Q10-Pad4_ Net-_Q10-Pad4_ /OUTb PMP4201
XQ4 Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q4-Pad3_ Net-_Q4-Pad4_ Net-_Q4-Pad5_ Net-_Q3-Pad2_ PMP5201
XQ6 Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q6-Pad3_ Net-_Q6-Pad4_ Net-_Q6-Pad5_ Net-_Q5-Pad2_ PMP5201
XQ9 Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q10-Pad1_ Net-_Q9-Pad4_ Net-_Q9-Pad5_ Net-_Q8-Pad2_ PMP5201
XQ11 Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q11-Pad3_ Net-_Q11-Pad4_ Net-_Q11-Pad5_ Net-_Q10-Pad2_ PMP5201
XQ13 Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q13-Pad3_ Net-_Q13-Pad4_ Net-_Q13-Pad5_ Net-_Q12-Pad2_ PMP5201
XQ15 Net-_Q11-Pad1_ Net-_Q11-Pad1_ Net-_Q15-Pad3_ Net-_Q15-Pad4_ Net-_Q15-Pad5_ Net-_Q14-Pad2_ PMP5201
XU5 Net-_Q11-Pad1_ Net-_Q15-Pad5_ Net-_R31-Pad2_ -15V GND Net-_R54-Pad1_ Net-_Q16-Pad2_ +15V TL072c
XU4 Net-_C9-Pad2_ Net-_C9-Pad1_ GND -15V NC_01 NC_02 NC_03 +15V TL072c
R34 +15V Net-_Q4-Pad5_ 51k
R37 +15V Net-_Q4-Pad4_ 51k
R39 +15V Net-_Q6-Pad5_ 51k
R42 +15V Net-_Q6-Pad4_ 51k
R44 +15V Net-_Q9-Pad5_ 51k
R46 +15V Net-_Q9-Pad4_ 51k
R48 +15V Net-_Q11-Pad5_ 51k
R50 +15V Net-_Q11-Pad4_ 51k
R52 +15V Net-_Q13-Pad5_ 51k
R55 +15V Net-_Q13-Pad4_ 51k
R58 +15V Net-_Q15-Pad5_ 51k
R60 +15V Net-_Q15-Pad4_ 51k
R32 Net-_Q3-Pad2_ /IN 750
R36 Net-_Q4-Pad3_ Net-_Q3-Pad2_ 750
R38 Net-_Q5-Pad2_ Net-_Q4-Pad3_ 750
R41 Net-_Q6-Pad3_ Net-_Q5-Pad2_ 750
R43 Net-_Q8-Pad2_ Net-_Q6-Pad3_ 750
R45 Net-_Q10-Pad1_ Net-_Q8-Pad2_ 750
R47 Net-_Q10-Pad2_ Net-_Q10-Pad1_ 750
R49 Net-_Q11-Pad3_ Net-_Q10-Pad2_ 750
R51 Net-_Q12-Pad2_ Net-_Q11-Pad3_ 750
R53 Net-_Q13-Pad3_ Net-_Q12-Pad2_ 750
R56 Net-_Q14-Pad2_ Net-_Q13-Pad3_ 750
R59 Net-_Q15-Pad3_ Net-_Q14-Pad2_ 750
R61 Net-_Q16-Pad2_ Net-_Q15-Pad3_ 750
R54 Net-_R54-Pad1_ /IN 10k
R57 Net-_Q16-Pad2_ Net-_R54-Pad1_ 10k
R35 Net-_C9-Pad1_ +5V 36k
R40 Net-_D1-Pad2_ Net-_C9-Pad2_ 1k
R30 +15V Net-_R30-Pad2_ 10k
R31 Net-_R30-Pad2_ Net-_R31-Pad2_ 10k
R33 Net-_R31-Pad2_ -15V 10k
C9 Net-_C9-Pad1_ Net-_C9-Pad2_ 47p
C10 +15V GND 0.1u
.end
