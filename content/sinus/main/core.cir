.title KiCad schematic
Q13 /OUTa Net-_Q13-Pad2_ Net-_Q11-Pad3_ BC846B
R17 Net-_Q13-Pad2_ Net-_Q15-Pad2_ 750
Q14 Net-_Q13-Pad2_ Net-_Q10-Pad2_ Net-_Q14-Pad3_ BC556B
R16 Net-_Q14-Pad3_ +15V 51k
Q15 /OUTb Net-_Q15-Pad2_ Net-_Q11-Pad3_ BC846B
R19 Net-_Q15-Pad2_ Net-_Q17-Pad2_ 750
Q16 Net-_Q15-Pad2_ Net-_Q10-Pad2_ Net-_Q16-Pad3_ BC556B
R18 Net-_Q16-Pad3_ +15V 51k
Q17 /OUTa Net-_Q17-Pad2_ Net-_Q11-Pad3_ BC846B
R21 Net-_Q17-Pad2_ Net-_Q19-Pad2_ 750
Q18 Net-_Q17-Pad2_ Net-_Q10-Pad2_ Net-_Q18-Pad3_ BC556B
R20 Net-_Q18-Pad3_ +15V 51k
Q19 /OUTb Net-_Q19-Pad2_ Net-_Q11-Pad3_ BC846B
R23 Net-_Q19-Pad2_ Net-_Q21-Pad2_ 750
Q20 Net-_Q19-Pad2_ Net-_Q10-Pad2_ Net-_Q20-Pad3_ BC556B
R22 Net-_Q20-Pad3_ +15V 51k
Q21 /OUTa Net-_Q21-Pad2_ Net-_Q11-Pad3_ BC846B
R25 Net-_Q21-Pad2_ Net-_Q23-Pad2_ 750
Q22 Net-_Q21-Pad2_ Net-_Q10-Pad2_ Net-_Q22-Pad3_ BC556B
R24 Net-_Q22-Pad3_ +15V 51k
Q23 /OUTb Net-_Q23-Pad2_ Net-_Q11-Pad3_ BC846B
R28 Net-_Q23-Pad2_ Net-_Q25-Pad2_ 750
Q24 Net-_Q23-Pad2_ Net-_Q10-Pad2_ Net-_Q24-Pad3_ BC556B
R27 Net-_Q24-Pad3_ +15V 51k
Q25 /OUTa Net-_Q25-Pad2_ Net-_Q11-Pad3_ BC846B
R31 Net-_Q25-Pad2_ Net-_Q27-Pad2_ 750
Q26 Net-_Q25-Pad2_ Net-_Q10-Pad2_ Net-_Q26-Pad3_ BC556B
R30 Net-_Q26-Pad3_ +15V 51k
Q11 /OUTb Net-_Q10-Pad1_ Net-_Q11-Pad3_ BC846B
R13 Net-_Q10-Pad1_ Net-_Q7-Pad1_ 750
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ BC556B
R14 Net-_Q10-Pad3_ +15V 51k
R15 Net-_Q13-Pad2_ Net-_Q10-Pad1_ 750
Q8 /OUTa Net-_Q7-Pad1_ Net-_Q11-Pad3_ BC846B
R10 Net-_Q7-Pad1_ Net-_Q5-Pad1_ 750
Q7 Net-_Q7-Pad1_ Net-_Q10-Pad2_ Net-_Q7-Pad3_ BC556B
R11 Net-_Q7-Pad3_ +15V 51k
Q6 /OUTb Net-_Q5-Pad1_ Net-_Q11-Pad3_ BC846B
R8 Net-_Q5-Pad1_ Net-_Q3-Pad1_ 750
Q5 Net-_Q5-Pad1_ Net-_Q10-Pad2_ Net-_Q5-Pad3_ BC556B
R9 Net-_Q5-Pad3_ +15V 51k
Q4 /OUTa Net-_Q3-Pad1_ Net-_Q11-Pad3_ BC846B
R4 Net-_Q3-Pad1_ /IN 750
Q3 Net-_Q3-Pad1_ Net-_Q10-Pad2_ Net-_Q3-Pad3_ BC556B
R6 Net-_Q3-Pad3_ +15V 51k
Q2 /OUTb /IN Net-_Q11-Pad3_ BC846B
Q27 /OUTb Net-_Q27-Pad2_ Net-_Q11-Pad3_ BC846B
R33 Net-_Q27-Pad2_ Net-_Q29-Pad2_ 750
Q28 Net-_Q27-Pad2_ Net-_Q10-Pad2_ Net-_Q28-Pad3_ BC556B
R32 Net-_Q28-Pad3_ +15V 51k
Q29 /OUTa Net-_Q29-Pad2_ Net-_Q11-Pad3_ BC846B
R29 Net-_Q29-Pad2_ Net-_R26-Pad1_ 10k
R26 Net-_R26-Pad1_ /IN 10k
XU1 +15V Net-_R3-Pad1_ Net-_R2-Pad1_ TL431
R2 Net-_R2-Pad1_ +15V 10k
R3 Net-_R3-Pad1_ Net-_R2-Pad1_ 10k
R5 -15V Net-_R3-Pad1_ 10k
XU3 Net-_Q10-Pad2_ Net-_Q26-Pad3_ Net-_R3-Pad1_ -15V GND Net-_R26-Pad1_ Net-_Q29-Pad2_ +15V TL072c
C2 +15V GND 0.1u
Q9 Net-_C1-Pad1_ GND Net-_D1-Pad2_ BC846B
Q12 Net-_Q11-Pad3_ GND Net-_D1-Pad2_ BC846B
D1 Net-_C1-Pad1_ Net-_D1-Pad2_ D1N4148
R12 Net-_C1-Pad2_ Net-_D1-Pad2_ 1k
XU2 Net-_C1-Pad2_ Net-_C1-Pad1_ GND -15V NC_01 NC_02 NC_03 +15V TL072c
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 47p
R7 +5V Net-_C1-Pad1_ 36k
.end
