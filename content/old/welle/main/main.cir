.title KiCad schematic
H1 MountingHole
H2 MountingHole
H3 MountingHole
H4 MountingHole
XU2 /shape_a Net-_D17-Pad2_ GND +15V GND Net-_R19-Pad2_ Net-_R32-Pad2_ Net-_C7-Pad1_ Net-_C7-Pad2_ GND -15V GND Net-_C8-Pad2_ Net-_C8-Pad1_ TL074c
XU1 Net-_R18-Pad2_ Net-_R15-Pad1_ Net-_R16-Pad1_ -15V GND Net-_R2-Pad1_ Net-_R8-Pad1_ +15V TL072c
R2 Net-_R2-Pad1_ /control 68k
R3 Net-_R2-Pad1_ /range 100k
R8 Net-_R8-Pad1_ Net-_R2-Pad1_ 100k
Q2 GND Net-_Q2-Pad2_ Net-_Q2-Pad3_ BC846B
R9 Net-_Q2-Pad2_ Net-_R8-Pad1_ 22k
R10 Net-_R10-Pad1_ Net-_Q2-Pad2_ 22k
R13 -15V Net-_Q2-Pad3_ 15k
XRV4 -15V Net-_R10-Pad1_ +15V RV4
R12 Net-_Q2-Pad3_ Net-_Q1-Pad3_ 33k
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ BC846B
Q3 Net-_Q3-Pad1_ GND Net-_Q1-Pad3_ BC846B
R1 Net-_Q1-Pad2_ /input 100k
R5 GND Net-_Q1-Pad2_ 680
R16 Net-_R16-Pad1_ Net-_Q3-Pad1_ 10k
R15 Net-_R15-Pad1_ Net-_Q1-Pad1_ 10k
R11 Net-_Q1-Pad1_ Net-_R11-Pad2_ 15k
R14 Net-_Q3-Pad1_ Net-_R14-Pad2_ 15k
R17 GND Net-_R16-Pad1_ 100k
R24 Net-_D17-Pad2_ /shape_a 100k
R23 Net-_R18-Pad2_ Net-_D17-Pad2_ 100k
D18 Net-_D17-Pad2_ Net-_D17-Pad1_ D1N4148
D17 Net-_D17-Pad1_ Net-_D17-Pad2_ D1N4148
R30 /shape_a Net-_D17-Pad1_ 33k
R31 GND Net-_D17-Pad1_ 2k7
R18 Net-_R15-Pad1_ Net-_R18-Pad2_ 100k
R33 Net-_R32-Pad2_ Net-_C7-Pad2_ 5k6
R35 Net-_C7-Pad1_ Net-_C8-Pad2_ 6k8
R32 Net-_R19-Pad2_ Net-_R32-Pad2_ 5k6
R34 Net-_C7-Pad2_ Net-_C7-Pad1_ 56k
D20 Net-_C7-Pad2_ Net-_C7-Pad1_ D1N4148
D19 Net-_C7-Pad1_ Net-_C7-Pad2_ D1N4148
R37 Net-_C8-Pad1_ /out 470
R36 Net-_C8-Pad2_ Net-_C8-Pad1_ 56k
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ D1N4148
D2 Net-_D1-Pad2_ Net-_D10-Pad1_ D1N4148
D3 Net-_D10-Pad1_ Net-_D11-Pad1_ D1N4148
D4 Net-_D11-Pad1_ Net-_D12-Pad1_ D1N4148
D5 Net-_D12-Pad1_ Net-_D13-Pad1_ D1N4148
D6 Net-_D13-Pad1_ Net-_D14-Pad1_ D1N4148
D7 Net-_D14-Pad1_ Net-_D15-Pad1_ D1N4148
D8 Net-_D15-Pad1_ /shape_a D1N4148
D16 /shape_a Net-_D15-Pad1_ D1N4148
D15 Net-_D15-Pad1_ Net-_D14-Pad1_ D1N4148
D14 Net-_D14-Pad1_ Net-_D13-Pad1_ D1N4148
D13 Net-_D13-Pad1_ Net-_D12-Pad1_ D1N4148
D12 Net-_D12-Pad1_ Net-_D11-Pad1_ D1N4148
D11 Net-_D11-Pad1_ Net-_D10-Pad1_ D1N4148
D10 Net-_D10-Pad1_ Net-_D1-Pad2_ D1N4148
D9 Net-_D1-Pad2_ Net-_D1-Pad1_ D1N4148
R19 Net-_D1-Pad1_ Net-_R19-Pad2_ 15k
R20 Net-_D10-Pad1_ Net-_R19-Pad2_ 15k
R21 Net-_D12-Pad1_ Net-_R19-Pad2_ 15k
R22 Net-_D14-Pad1_ Net-_R19-Pad2_ 15k
R25 Net-_C7-Pad2_ Net-_D1-Pad2_ 15k
R26 Net-_C7-Pad2_ Net-_D11-Pad1_ 15k
R27 Net-_C7-Pad2_ Net-_D13-Pad1_ 15k
R28 Net-_C7-Pad2_ Net-_D15-Pad1_ 15k
R29 /shape_b Net-_R19-Pad2_ 27k
XRV5 Net-_R11-Pad2_ +15V Net-_R14-Pad2_ RV5
.end
