.title KiCad schematic
R3 Net-_Q1-Pad1_ +5V 220
R10 Net-_C1-Pad2_ +5V 220
R14 Net-_Q3-Pad4_ -15V 10k
C2 Net-_C2-Pad1_ +5V 1n
R12 Net-_Q3-Pad4_ Net-_C1-Pad2_ 10k
R6 Net-_Q1-Pad4_ Net-_Q13-Pad6_ 1k
R16 Net-_Q4-Pad1_ +5V 220
R20 Net-_Q4-Pad2_ +5V 220
R22 Net-_Q6-Pad4_ -15V 10k
C5 Net-_C5-Pad1_ +5V 1n
R21 Net-_Q6-Pad4_ Net-_Q4-Pad2_ 10k
R18 Net-_Q4-Pad4_ Net-_Q13-Pad3_ 1k
R17 Net-_Q4-Pad2_ Net-_Q3-Pad4_ 10k
R23 Net-_Q7-Pad1_ +5V 220
R26 Net-_Q7-Pad2_ +5V 220
R28 Net-_Q9-Pad4_ -15V 10k
C6 Net-_C6-Pad1_ +5V 1n
R27 Net-_Q9-Pad4_ Net-_Q7-Pad2_ 10k
R25 Net-_Q7-Pad4_ Net-_Q14-Pad3_ 1k
R24 Net-_Q7-Pad2_ Net-_Q6-Pad4_ 10k
R29 Net-_Q10-Pad1_ +5V 220
R32 Net-_Q10-Pad2_ +5V 220
R36 Net-_C8-Pad1_ -15V 10k
C7 Net-_C7-Pad1_ +5V 1n
R35 Net-_C8-Pad1_ Net-_Q10-Pad2_ 10k
R31 Net-_Q10-Pad4_ Net-_Q14-Pad6_ 1k
R30 Net-_Q10-Pad2_ Net-_Q9-Pad4_ 10k
XU1 Net-_R11-Pad2_ Net-_R4-Pad1_ GND -15V GND Net-_Q15-Pad6_ Net-_R19-Pad2_ +15V TL072c
R15 +15V Net-_Q15-Pad6_ 1M
R19 Net-_Q13-Pad4_ Net-_R19-Pad2_ 2.2k
R11 Net-_Q15-Pad1_ Net-_R11-Pad2_ 27k
R13 Net-_Q15-Pad1_ GND 1k
R7 Net-_R11-Pad2_ Net-_R4-Pad1_ 51k
R4 Net-_R4-Pad1_ /CV 100k
R5 Net-_R4-Pad1_ -15V 200k
XU2 /OUT Net-_R33-Pad2_ GND -15V NC_01 NC_02 NC_03 +15V TL072c
R34 /OUT Net-_R33-Pad2_ 100k
R33 Net-_C8-Pad2_ Net-_R33-Pad2_ 10k
XRV1 GND Net-_R2-Pad2_ /OUT RV1
R2 Net-_C1-Pad1_ Net-_R2-Pad2_ 10k
R1 Net-_C1-Pad1_ /IN 10k
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 10u
XQ1 Net-_Q1-Pad1_ Net-_C1-Pad2_ Net-_C2-Pad1_ Net-_Q1-Pad4_ Net-_Q1-Pad4_ Net-_Q1-Pad6_ DMMT3904W
XQ4 Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_C5-Pad1_ Net-_Q4-Pad4_ Net-_Q4-Pad4_ Net-_Q4-Pad6_ DMMT3904W
XQ7 Net-_Q7-Pad1_ Net-_Q7-Pad2_ Net-_C6-Pad1_ Net-_Q7-Pad4_ Net-_Q7-Pad4_ Net-_Q7-Pad6_ DMMT3904W
XQ10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_C7-Pad1_ Net-_Q10-Pad4_ Net-_Q10-Pad4_ Net-_Q10-Pad6_ DMMT3904W
XQ3 Net-_C2-Pad1_ Net-_Q3-Pad2_ +15V Net-_Q3-Pad4_ Net-_Q3-Pad2_ +15V DMMT3904W
XQ6 Net-_C5-Pad1_ Net-_Q6-Pad2_ +15V Net-_Q6-Pad4_ Net-_Q6-Pad2_ +15V DMMT3904W
XQ9 Net-_C6-Pad1_ Net-_Q9-Pad2_ +15V Net-_Q9-Pad4_ Net-_Q9-Pad2_ +15V DMMT3904W
XQ12 Net-_C7-Pad1_ Net-_Q12-Pad2_ +15V Net-_C8-Pad1_ Net-_Q12-Pad2_ +15V DMMT3904W
XQ2 Net-_Q1-Pad6_ Net-_Q1-Pad6_ Net-_C2-Pad1_ +15V +15V Net-_Q1-Pad6_ DMMT3906W
XQ5 Net-_Q4-Pad6_ Net-_Q4-Pad6_ Net-_C5-Pad1_ +15V +15V Net-_Q4-Pad6_ DMMT3906W
XQ8 Net-_Q7-Pad6_ Net-_Q7-Pad6_ Net-_C6-Pad1_ +15V +15V Net-_Q7-Pad6_ DMMT3906W
XQ11 Net-_Q10-Pad6_ Net-_Q10-Pad6_ Net-_C7-Pad1_ +15V +15V Net-_Q10-Pad6_ DMMT3906W
XQ13 GND GND Net-_Q13-Pad3_ Net-_Q13-Pad4_ Net-_Q13-Pad4_ Net-_Q13-Pad6_ DMMT3904W
XQ14 GND GND Net-_Q14-Pad3_ Net-_Q13-Pad4_ Net-_Q13-Pad4_ Net-_Q14-Pad6_ DMMT3904W
XQ15 Net-_Q15-Pad1_ NC_04 NC_05 NC_06 Net-_Q13-Pad4_ Net-_Q15-Pad6_ DMMT3904W
C8 Net-_C8-Pad1_ Net-_C8-Pad2_ 10u
.end
