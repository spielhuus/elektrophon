.title KiCad schematic
R36 Net-_C9-Pad2_ /OUT 100k
R33 Net-_C10-Pad1_ Net-_C9-Pad2_ 100k
R39 /OUT Net-_J10-PadT_ 1k
XJ10 GND Net-_J10-PadT_ NC_01 OUT
R31 Net-_C10-Pad2_ Net-_C10-Pad1_ 100k
R24 /MIX_1 Net-_C10-Pad2_ 100k
R25 /MIX_2 Net-_C10-Pad2_ 100k
R26 /MIX_3 Net-_C10-Pad2_ 100k
R27 /MIX_4 Net-_C10-Pad2_ 100k
R22 Net-_R18-Pad1_ Net-_J9-PadT_ 1k
XJ9 GND Net-_J9-PadT_ /MIX_4 OUT_4
R21 Net-_R17-Pad1_ Net-_J8-PadT_ 1k
XJ8 GND Net-_J8-PadT_ /MIX_3 OUT_3
R20 Net-_R16-Pad1_ Net-_J7-PadT_ 1k
XJ7 GND Net-_J7-PadT_ /MIX_2 OUT_2
R18 Net-_R18-Pad1_ Net-_R14-Pad1_ 100k
R10 Net-_R10-Pad1_ GND 47k
R9 /IN_4 Net-_R10-Pad1_ 47k
R14 Net-_R14-Pad1_ /IN_4 100k
XRV4 GND Net-_R10-Pad1_ /IN_4 voltage_divider_4
XJ5 GND /IN_4 NC_02 IN_4
R17 Net-_R17-Pad1_ Net-_R13-Pad1_ 100k
R8 Net-_R7-Pad2_ GND 47k
R7 /IN_3 Net-_R7-Pad2_ 47k
R13 Net-_R13-Pad1_ /IN_3 100k
XRV3 GND Net-_R7-Pad2_ /IN_3 voltage_divider_3
XJ4 GND /IN_3 NC_03 IN_3
R16 Net-_R16-Pad1_ Net-_R12-Pad1_ 100k
R6 Net-_R5-Pad2_ GND 47k
R5 /IN_2 Net-_R5-Pad2_ 47k
R12 Net-_R12-Pad1_ /IN_2 100k
XRV2 GND Net-_R5-Pad2_ /IN_2 voltage_divider_2
XJ3 GND /IN_2 NC_04 IN_2
R15 Net-_R15-Pad1_ Net-_R11-Pad1_ 100k
R4 Net-_R3-Pad2_ GND 47k
R3 /IN_1 Net-_R3-Pad2_ 47k
R11 Net-_R11-Pad1_ /IN_1 100k
XRV1 GND Net-_R3-Pad2_ /IN_1 voltage_divider_1
R19 Net-_R15-Pad1_ Net-_J6-PadT_ 1k
XJ6 GND Net-_J6-PadT_ /MIX_1 OUT_1
XJ2 GND /IN_1 /REF IN_1
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ 100p
XU5 Net-_R18-Pad1_ Net-_R14-Pad1_ Net-_R10-Pad1_ -15V Net-_R34-Pad2_ /IN_4 Net-_R34-Pad2_ +15V TL072c
D1 GND Net-_D1-Pad2_ LED2
D2 GND Net-_D2-Pad2_ LED2
XU6 Net-_U6-Pad1_ GND Net-_U6-Pad1_ -15V Net-_R28-Pad2_ /OUT Net-_R28-Pad2_ +15V TL072c
D3 GND Net-_D3-Pad2_ LED2
D4 GND Net-_D4-Pad2_ LED2
XU4 Net-_R17-Pad1_ Net-_R13-Pad1_ Net-_R7-Pad2_ -15V Net-_R30-Pad2_ /IN_3 Net-_R30-Pad2_ +15V TL072c
D5 GND Net-_D5-Pad2_ LED2
R29 Net-_D1-Pad2_ Net-_R29-Pad2_ 500
R30 Net-_D3-Pad2_ Net-_R30-Pad2_ 500
R28 Net-_D5-Pad2_ Net-_R28-Pad2_ 500
R32 Net-_D2-Pad2_ Net-_R32-Pad2_ 500
R34 Net-_D4-Pad2_ Net-_R34-Pad2_ 500
XU7 Net-_C10-Pad1_ Net-_C10-Pad2_ GND -15V GND Net-_C9-Pad2_ /OUT +15V TL072c
XU2 Net-_R15-Pad1_ Net-_R11-Pad1_ Net-_R3-Pad2_ -15V Net-_R29-Pad2_ /IN_1 Net-_R29-Pad2_ +15V TL072c
XU3 Net-_R16-Pad1_ Net-_R12-Pad1_ Net-_R5-Pad2_ -15V Net-_R32-Pad2_ /IN_2 Net-_R32-Pad2_ +15V TL072c
C9 /OUT Net-_C9-Pad2_ 100p
.end
