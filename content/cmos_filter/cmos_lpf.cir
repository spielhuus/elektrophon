.title cmos lpf
.include /home/etienne/Documents/elektrophon/lib/spice/opamp/TL072.lib
V1 +5V 0 DC 15
V3 -5V 0 DC -15
V2 IN 0 DC 5 AC 5V SIN(0 5V 1k)
X1 0 gate_in_1 +5V -5V gate_out_1 TL072
C3 IN C3 100uF
R1 C3 gate_in_1 10kOhm
C1 gate_in_1 gate_out_1 10nF
R2 gate_in_1 gate_out_1 100kOhm
